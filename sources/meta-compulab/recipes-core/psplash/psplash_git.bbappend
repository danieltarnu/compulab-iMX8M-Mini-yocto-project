FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SPLASH_IMAGES = "file://compulab-logo-img.h;outsuffix=default"
